# Keil uVision project MW-V_029.uvproj, settings and files
target MW-V_029 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: NUC029KGE Nuvoton
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0x3FFFF) CLOCK(72000000) CPUTYPE("Cortex-M0")
  output: MW-V_029 +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\lib\CMSIS\Include;..\lib\Device\Nuvoton\NUC029xGE\Include;..\lib\StdDriver\inc;..\src\core\include;..\src\driver\include;..\src\io\include;..\src\global;..\src\server\include;..\src\driver\audio
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_NUC029xGE.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group chip
    ../lib/Device/Nuvoton/NUC029xGE/Source/: system_NUC029xGE.c
    ../lib/Device/Nuvoton/NUC029xGE/Source/ARM/: startup_NUC029xGE.s
  group core
    ../src/core/: core.c core_msg.c
    ../src/global/: hal_timer0.c
  group 029
    ../: main.c
  group io
    ../src/io/: io_gpio.c io_i2c.c io_uart.c io_usci_uart.c io_ii2c.c
  group drv
    ../src/driver/: drv_4G_model.c drv_power.c drv_nuc031.c drv_led.c drv_ irkey.c drv_gpio_key.c
    ../src/driver/audio/: drv_adc_pcm1862.c drv_audio.c drv_dap_tas3251.c drv_dap_tas5825.c
  group lib
    ../lib/StdDriver/src/: retarget.c sys.c clk.c uart.c i2c.c gpio.c adc.c usci_uart.c timer.c rtc.c
  group global
    ../src/global/: tym_global.c
  group srv
    ../src/server/battery/: srv_battery.c
    ../src/server/led/: srv_led.c
    ../src/server/audio/: srv_audio.c
    ../src/server/rtc/: srv_rtc.c
    ../src/server/key/: srv_key.c
